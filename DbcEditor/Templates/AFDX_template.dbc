VERSION ""


NS_ : 
	NS_DESC_
	CM_
	BA_DEF_
	BA_
	VAL_
	CAT_DEF_
	CAT_
	FILTER
	BA_DEF_DEF_
	EV_DATA_
	ENVVAR_DATA_
	SGTYPE_
	SGTYPE_VAL_
	BA_DEF_SGTYPE_
	BA_SGTYPE_
	SIG_TYPE_REF_
	VAL_TABLE_
	SIG_GROUP_
	SIG_VALTYPE_
	SIGTYPE_VALTYPE_
	BO_TX_BU_
	BA_DEF_REL_
	BA_REL_
	BA_DEF_DEF_REL_
	BU_SG_REL_
	BU_EV_REL_
	BU_BO_REL_
	SG_MUL_VAL_

BS_:

BU_:




CM_ "DBC template for AFDX";
BA_DEF_  "TemplateVersion" STRING ;
BA_DEF_ BU_  "ICMP_inVLmaxFrame" INT 17 1471;
BA_DEF_ BU_  "ICMP_inVLrma" ENUM  "False","True";
BA_DEF_ BU_  "ICMP_inVLintCheck" ENUM  "False","True";
BA_DEF_ BU_  "ICMP_inVLskewmax" INT 0 65535;
BA_DEF_ BU_  "ICMP_inVLbag" INT 1 128;
BA_DEF_ BU_  "ICMP_inVLnetSel" ENUM  "NETWORK_NONE","NETWORK_A","NETWORK_B","NETWORK_AB";
BA_DEF_ BU_  "ICMP_inVLid" INT 1 65535;
BA_DEF_ BU_  "ICMP_outVLmaxFrame" INT 17 1471;
BA_DEF_ BU_  "ICMP_outVLbag" INT 1 128;
BA_DEF_ BU_  "ICMP_outVLnetSel" ENUM  "NETWORK_NONE","NETWORK_A","NETWORK_B","NETWORK_AB";
BA_DEF_ BU_  "ICMP_outsubVLid" INT 1 4;
BA_DEF_ BU_  "ICMP_outVLid" INT 1 65535;
BA_DEF_ BU_  "ICMP_destIP" STRING ;
BA_DEF_ BU_  "ICMP_name" STRING ;
BA_DEF_  "Manufacturer" STRING ;
BA_DEF_  "VersionNumber" INT 0 999999999;
BA_DEF_  "VersionYear" INT 0 99;
BA_DEF_  "VersionMonth" INT 0 12;
BA_DEF_  "VersionWeek" INT 0 52;
BA_DEF_  "VersionDay" INT 0 31;
BA_DEF_ SG_  "AfdxFSaddr" INT 4 8192;
BA_DEF_ SG_  "AfdxFDSaddr" INT 8 8192;
BA_DEF_ SG_  "AfdxFDSspareLen" INT 0 8192;
BA_DEF_ SG_  "AfdxFDSlength" INT 0 8192;
BA_DEF_ SG_  "AfdxFDSname" STRING ;
BA_DEF_ SG_  "AfdxSignalType" ENUM  "Boolean","Enumerate","Float","Integer","Opaque","String","Status";
BA_DEF_ BO_  "AfdxTxPortId" INT 1 65535;
BA_DEF_ BO_  "AfdxPortMasterName" STRING ;
BA_DEF_ BO_  "AfdxMsgRefreshDef" INT 0 0;
BA_DEF_ BO_  "AfdxMsgTxRate" INT 0 0;
BA_DEF_ BO_  "AfdxVLbufSize" INT 1 8192;
BA_DEF_ BO_  "AfdxVLdestUDP" INT 0 65535;
BA_DEF_ BO_  "AfdxVLsrcUDP" INT 0 65535;
BA_DEF_ BO_  "AfdxVLdestIP" STRING ;
BA_DEF_ BO_  "AfdxVLsrcIP" STRING ;
BA_DEF_ BO_  "AfdxVLipFrag" ENUM  "True","False";
BA_DEF_ BO_  "AfdxVLportChar" ENUM  "Unknown","SAP","Sampling","Queuing";
BA_DEF_ BO_  "AfdxVLportType" ENUM  "Unknown","SAP","AFDX Communication Port";
BA_DEF_ BO_  "AfdxVLsubVLId" INT 0 4;
BA_DEF_ BO_  "AfdxVLsubVL" INT 0 4;
BA_DEF_ BO_  "AfdxVLskewMax" INT 0 65535;
BA_DEF_ BO_  "AfdxVLintCheck" ENUM  "True","False";
BA_DEF_ BO_  "AfdxVLrma" STRING ;
BA_DEF_ BO_  "AfdxVLmaxFrame" INT 17 1471;
BA_DEF_ BO_  "AfdxVLbag" INT 1 128;
BA_DEF_ BO_  "AfdxVLnetSel" ENUM  "NETWORK_NONE","NETWORK_A","NETWORK_B","NETWORK_AB";
BA_DEF_ BO_  "AfdxVLname" STRING ;
BA_DEF_ BO_  "AfdxVLid" INT 1 65535;
BA_DEF_ BO_  "AfdxVLportSpeed" INT 10 100;
BA_DEF_ BO_  "AfdxGroupId" INT 0 65535;
BA_DEF_ BO_  "AfdxParentId" INT 0 65535;
BA_DEF_ BU_  "AfdxEquipment" STRING ;
BA_DEF_ SG_  "SignalTypeExt" ENUM  "No","StringType","ByteArray";
BA_DEF_ SG_  "DefaultValue" STRING ;
BA_DEF_ BU_  "NodeLayerModules" STRING ;
BA_DEF_  "BusType" STRING ;
BA_DEF_  "ToolVersion" STRING ;
BA_DEF_  "ToolName" STRING ;
BA_DEF_ BU_  "CANoeStartDelay" INT 0 0;
BA_DEF_ BU_  "CANoeJitterMin" INT 0 0;
BA_DEF_ BU_  "CANoeJitterMax" INT 0 0;
BA_DEF_ BU_  "ECU" STRING ;
BA_DEF_ BU_  "CANoeDrift" INT 0 0;
BA_DEF_DEF_  "TemplateVersion" "2.2.0.0";
BA_DEF_DEF_  "ICMP_inVLmaxFrame" 1471;
BA_DEF_DEF_  "ICMP_inVLrma" "True";
BA_DEF_DEF_  "ICMP_inVLintCheck" "True";
BA_DEF_DEF_  "ICMP_inVLskewmax" 0;
BA_DEF_DEF_  "ICMP_inVLbag" 128;
BA_DEF_DEF_  "ICMP_inVLnetSel" "NETWORK_AB";
BA_DEF_DEF_  "ICMP_inVLid" 2000;
BA_DEF_DEF_  "ICMP_outVLmaxFrame" 1471;
BA_DEF_DEF_  "ICMP_outVLbag" 128;
BA_DEF_DEF_  "ICMP_outVLnetSel" "NETWORK_AB";
BA_DEF_DEF_  "ICMP_outsubVLid" 1;
BA_DEF_DEF_  "ICMP_outVLid" 1000;
BA_DEF_DEF_  "ICMP_destIP" "0.0.0.0";
BA_DEF_DEF_  "ICMP_name" "ICMP_unnamed";
BA_DEF_DEF_  "Manufacturer" "";
BA_DEF_DEF_  "VersionNumber" 0;
BA_DEF_DEF_  "VersionYear" 0;
BA_DEF_DEF_  "VersionMonth" 1;
BA_DEF_DEF_  "VersionWeek" 1;
BA_DEF_DEF_  "VersionDay" 1;
BA_DEF_DEF_  "AfdxFSaddr" 4;
BA_DEF_DEF_  "AfdxFDSaddr" 8;
BA_DEF_DEF_  "AfdxFDSspareLen" 0;
BA_DEF_DEF_  "AfdxFDSlength" 0;
BA_DEF_DEF_  "AfdxFDSname" "";
BA_DEF_DEF_  "AfdxSignalType" "Boolean";
BA_DEF_DEF_  "AfdxTxPortId" 1;
BA_DEF_DEF_  "AfdxPortMasterName" "DBC_default";
BA_DEF_DEF_  "AfdxMsgRefreshDef" 0;
BA_DEF_DEF_  "AfdxMsgTxRate" 255;
BA_DEF_DEF_  "AfdxVLbufSize" 2048;
BA_DEF_DEF_  "AfdxVLdestUDP" 1;
BA_DEF_DEF_  "AfdxVLsrcUDP" 1;
BA_DEF_DEF_  "AfdxVLdestIP" "0:0:0:0";
BA_DEF_DEF_  "AfdxVLsrcIP" "0:0:0:0";
BA_DEF_DEF_  "AfdxVLipFrag" "True";
BA_DEF_DEF_  "AfdxVLportChar" "Sampling";
BA_DEF_DEF_  "AfdxVLportType" "AFDX Communication Port";
BA_DEF_DEF_  "AfdxVLsubVLId" 1;
BA_DEF_DEF_  "AfdxVLsubVL" 1;
BA_DEF_DEF_  "AfdxVLskewMax" 0;
BA_DEF_DEF_  "AfdxVLintCheck" "True";
BA_DEF_DEF_  "AfdxVLrma" "Active";
BA_DEF_DEF_  "AfdxVLmaxFrame" 1471;
BA_DEF_DEF_  "AfdxVLbag" 128;
BA_DEF_DEF_  "AfdxVLnetSel" "NETWORK_AB";
BA_DEF_DEF_  "AfdxVLname" "DBC_default";
BA_DEF_DEF_  "AfdxVLid" 1;
BA_DEF_DEF_  "AfdxVLportSpeed" 100;
BA_DEF_DEF_  "AfdxGroupId" 0;
BA_DEF_DEF_  "AfdxParentId" 0;
BA_DEF_DEF_  "AfdxEquipment" "<unknown>";
BA_DEF_DEF_  "SignalTypeExt" "No";
BA_DEF_DEF_  "DefaultValue" "";
BA_DEF_DEF_  "NodeLayerModules" "";
BA_DEF_DEF_  "BusType" "AFDX";
BA_DEF_DEF_  "ToolVersion" "x.y.z.n";
BA_DEF_DEF_  "ToolName" "manually";
BA_DEF_DEF_  "CANoeStartDelay" 0;
BA_DEF_DEF_  "CANoeJitterMin" 0;
BA_DEF_DEF_  "CANoeJitterMax" 0;
BA_DEF_DEF_  "ECU" "";
BA_DEF_DEF_  "CANoeDrift" 0;

