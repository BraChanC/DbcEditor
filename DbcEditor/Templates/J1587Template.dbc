VERSION ""


NS_ : 
	NS_DESC_
	CM_
	BA_DEF_
	BA_
	VAL_
	CAT_DEF_
	CAT_
	FILTER
	BA_DEF_DEF_
	EV_DATA_
	ENVVAR_DATA_
	SGTYPE_
	SGTYPE_VAL_
	BA_DEF_SGTYPE_
	BA_SGTYPE_
	SIG_TYPE_REF_
	VAL_TABLE_
	SIG_GROUP_
	SIG_VALTYPE_
	SIGTYPE_VALTYPE_
	BO_TX_BU_
	BA_DEF_REL_
	BA_REL_
	BA_DEF_DEF_REL_
	BU_SG_REL_
	BU_EV_REL_
	BU_BO_REL_
	SG_MUL_VAL_

BS_:

BU_:
VAL_TABLE_ VtSitg_RqTempClutchDisengage 3 "NotAvailable" 2 "Error" 1 "ClutchDisengegementRequested" 0 "NoRequest" ;
VAL_TABLE_ VTSig_Lamp 3 "NotAvailable" 2 "Error" 1 "On" 0 "Off" ;
VAL_TABLE_ VTSig_Active 1 "Active" 0 "not Active" ;
VAL_TABLE_ VTSig_OnOff 3 "NotAvailable" 2 "Error" 1 "On" 0 "Off" ;




BA_DEF_  "J1587ProprietaryFormat" ENUM  "undefined","Volvo";
BA_DEF_  "BusType" STRING ;
BA_DEF_ BO_  "J1587CycleTime" INT 0 100000;
BA_DEF_ BU_  "NmStationAddress" INT 0 255;
BA_DEF_ BO_  "J1708Priority" INT 1 8;
BA_DEF_DEF_  "J1587ProprietaryFormat" "undefined";
BA_DEF_DEF_  "BusType" "J1708";
BA_DEF_DEF_  "J1587CycleTime" 0;
BA_DEF_DEF_  "NmStationAddress" 0;
BA_DEF_DEF_  "J1708Priority" 6;
